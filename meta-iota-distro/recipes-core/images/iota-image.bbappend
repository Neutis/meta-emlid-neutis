IMAGE_INSTALL_append += "coreutils"
IMAGE_INSTALL_append += "util-linux"
