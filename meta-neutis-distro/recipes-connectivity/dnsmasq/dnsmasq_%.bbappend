FILESEXTRAPATHS =. "${THISDIR}/${PN}:"

SYSTEMD_AUTO_ENABLE = "disable"
